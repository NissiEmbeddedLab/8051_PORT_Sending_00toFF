# Keil uVision project 1_Sending_00_to_FF_through_PORT1.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: 1_Sending_00_to_FF_through_PORT1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 1_Sending_00_to_FF_through_PORT1.c
